
		ORG		1200H

		DI
		LD		HL,0000H
		LD		DE,2000H
		LD		BC,1000H
		LDIR
		OUT		(0E0H),A
		LD		HL,2000H
		LD		DE,0000H
		LD		BC,1000H
		LDIR
		LD		HL,ADRS
		LD		DE,DATA
		LD		B,0FH
LOP1:	PUSH	BC
		LD		C,(HL)
		INC		HL
		LD		B,(HL)
		LD		A,(DE)
		LD		(BC),A
		POP		BC
		INC		DE
		INC		HL
		DEC		B
		JR		NZ,LOP1
		
		JP		00ADH

ADRS:	DW		0437H,0438H,0439H
		DW		0476H,0477H,0478H
		DW		04D9H,04DAH,04DBH
		DW		04F9H,04FAH,04FBH
		DW		0589H,058AH,058BH

DATA:	DB		0C3H,04H,0F0H
		DB		0C3H,07H,0F0H
		DB		0C3H,0AH,0F0H
		DB		0C3H,0DH,0F0H
		DB		0C3H,010H,0F0H

		END
